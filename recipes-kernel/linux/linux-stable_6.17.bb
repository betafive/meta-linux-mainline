# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "17"
LINUX_VPATCH = "13"
SRCREV = "6609c4d49ebe220a5c40d3105c3f0e68f569ba1a"
require linux-stable.inc
