# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "18"
LINUX_VPATCH = "64"
SRCREV = "fd7cfd39c88596fec816639ad83cbf3e9d316372"
require linux-stable.inc
