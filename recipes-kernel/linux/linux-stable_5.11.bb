LINUX_VMAJOR = "5"
LINUX_VMINOR = "11"
LINUX_VPATCH = "6"
LINUX_SRCREV = "0985dc528812f818fa94366354b9031a2aebc306"
LINUX_SHA256 = "e970796a6ed451c59225b32ca525520442647c072ec1867e1aac508ad9c1ac09"

require linux-stable.inc
