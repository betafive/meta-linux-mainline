# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "5"
LINUX_VMINOR = "15"
LINUX_VPATCH = "226"
SRCREV = "4f2df9a01754521fbba3493e8ad91ef65515e68c"
require linux-stable.inc
