# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "5"
LINUX_VMINOR = "14"
LINUX_VPATCH = "18"
LINUX_SHA256_TARBALL = "7e068b5e0d26a62b10e5320b25dce57588cbbc6f781c090442138c9c9c3271b2"
LINUX_SHA256_PATCH = "93dd7867d4c3d6fe605cfd8c3f0f96822844bc66b3ff248df673556f37ac0b2c"
require linux-stable.inc
