# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "0"
LINUX_VPATCH = "15"
LINUX_SHA256_TARBALL = "5c2443a5538de52688efb55c27ab0539c1f5eb58c0cfd16a2b9fbb08fd81788e"
LINUX_SHA256_PATCH = "8d64d2220d8a199a2d777e9af952a4ee89c58b8e4c6e45852fcfb961681ad1a9"
require linux-stable.inc
