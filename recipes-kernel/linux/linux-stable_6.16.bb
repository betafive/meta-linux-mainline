# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "16"
LINUX_VPATCH = "8"
SRCREV = "62dae019823123ce3baa50e680219e2beb9a63a5"
require linux-stable.inc
