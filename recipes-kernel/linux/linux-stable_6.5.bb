# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "5"
LINUX_VPATCH = "6"
LINUX_SHA256_TARBALL = "7a574bbc20802ea76b52ca7faf07267f72045e861b18915c5272a98c27abf884"
LINUX_SHA256_PATCH = "3f7966f27b5fd4d821297a8ee1a01694f4bf464228b192ab468f0e02186e7bb6"
require linux-stable.inc
