LINUX_VMAJOR = "5"
LINUX_VMINOR = "7"
LINUX_VPATCH = "7"
LINUX_SRCREV = "fb6c7905238010236cf0750b209ce9162222eb97"
LINUX_SHA256 = "f840b9679283343c165516585c3070ebb277528721c890e9410a58e9d071ee7f"

require linux-stable.inc
