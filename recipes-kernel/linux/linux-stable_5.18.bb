# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "5"
LINUX_VMINOR = "18"
LINUX_VPATCH = "5"
LINUX_SHA256_TARBALL = "51f3f1684a896e797182a0907299cc1f0ff5e5b51dd9a55478ae63a409855cee"
LINUX_SHA256_PATCH = "fb0c52d5628f332ffe10ebaa1419c7518198f4ffe757e39c9a80229b480a36ca"
require linux-stable.inc
