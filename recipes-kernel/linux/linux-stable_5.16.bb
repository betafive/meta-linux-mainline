# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "5"
LINUX_VMINOR = "16"
LINUX_VPATCH = "20"
LINUX_SHA256_TARBALL = "027d7e8988bb69ac12ee92406c3be1fe13f990b1ca2249e226225cd1573308bb"
LINUX_SHA256_PATCH = "619cd0e39db62b581107cd71dbc1fc52654f94d4306fd02e806ab599f06d0cd8"
require linux-stable.inc
