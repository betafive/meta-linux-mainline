LINUX_VMAJOR = "5"
LINUX_VMINOR = "12"
LINUX_VPATCH = "9"
LINUX_SRCREV = "5a973f1903850a6257856e72959354eb856085ae"
LINUX_SHA256 = "c7fabef5754271cd12f2d3a9ae237ed91c6fce09cec3895400d48194110ce76d"

require linux-stable.inc
