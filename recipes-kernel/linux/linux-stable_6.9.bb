# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "9"
LINUX_VPATCH = "8"
LINUX_SHA256_TARBALL = "24fa01fb989c7a3e28453f117799168713766e119c5381dac30115f18f268149"
LINUX_SHA256_PATCH = "cf7dbb88fa35557195f8cde7fd05ec873db95af91cbcae7472a13d9bc9c5cbaa"
require linux-stable.inc
