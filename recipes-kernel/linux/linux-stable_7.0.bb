# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "7"
LINUX_VMINOR = "0"
LINUX_VPATCH = "11"
SRCREV = "bb532bfaf7919c7c98caab81864e9ce2646e11e3"
require linux-stable.inc
