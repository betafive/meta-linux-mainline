# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "15"
LINUX_VPATCH = "5"
SRCREV = "7b59ab988c01c190f1b528cf750d6f33b738d1e2"
require linux-stable.inc
