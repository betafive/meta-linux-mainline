# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "10"
LINUX_VPATCH = "12"
LINUX_SHA256_TARBALL = "774698422ee54c5f1e704456f37c65c06b51b4e9a8b0866f34580d86fef8e226"
LINUX_SHA256_PATCH = "85994d53de093fff217962232b49629b6c5607eae03fa4e234fed740a16ff665"
require linux-stable.inc
