LINUX_VMAJOR = "4"
LINUX_VMINOR = "4"
LINUX_VPATCH = "257"
LINUX_SRCREV = "788437ba4c80d0d5e32ceaa28f872343e87236f5"
LINUX_SHA256 = "3e067c5625b6a1201325c45c9b9e75f87e768cfbb9426f5f173dee73dc234b5a"

require linux-stable.inc
