# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "7"
LINUX_VMINOR = "1"
LINUX_VPATCH = "11"
SRCREV = "843fd19fe9a27f36662b38328a51890e6b0f1586"
require linux-stable.inc
