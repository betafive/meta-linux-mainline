# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "19"
LINUX_VPATCH = "7"
SRCREV = "0d87da0c7e74868a63d2b856454122b5fb30d341"
require linux-stable.inc
