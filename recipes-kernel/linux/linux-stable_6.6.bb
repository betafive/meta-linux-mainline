# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "6"
LINUX_VPATCH = "163"
SRCREV = "e2bb30811e063ce0db964484357973b855b06572"
require linux-stable.inc
