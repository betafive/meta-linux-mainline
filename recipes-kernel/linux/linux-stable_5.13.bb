# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "5"
LINUX_VMINOR = "13"
LINUX_VPATCH = "1"
LINUX_SHA256_TARBALL = "3f6baa97f37518439f51df2e4f3d65a822ca5ff016aa8e60d2cc53b95a6c89d9"
LINUX_SHA256_PATCH = "b356073468ffaee4e2ff507a521b70d130eab6542c8d9012168548f2cf554a79"
require linux-stable.inc
