# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "14"
LINUX_VPATCH = "5"
SRCREV = "aeaee199900ee618e676698d21e4ac788f54572f"
require linux-stable.inc
