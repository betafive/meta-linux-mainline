# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "4"
LINUX_VPATCH = "3"
LINUX_SHA256_TARBALL = "8fa0588f0c2ceca44cac77a0e39ba48c9f00a6b9dc69761c02a5d3efac8da7f3"
LINUX_SHA256_PATCH = "267212c05942ff82d0a9269ffa91067487d07ccb511890b187d581d33ba44040"
require linux-stable.inc
