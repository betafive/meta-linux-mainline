# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "4"
LINUX_VMINOR = "9"
LINUX_VPATCH = "281"
LINUX_SHA256_TARBALL = "029098dcffab74875e086ae970e3828456838da6e0ba22ce3f64ef764f3d7f1a"
LINUX_SHA256_PATCH = "8e5b6957f6dc0819c52c855bb09d77b10955955b18ea98d3103c09aaf3930230"
require linux-stable.inc
