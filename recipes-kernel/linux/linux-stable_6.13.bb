# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "13"
LINUX_VPATCH = "9"
SRCREV = "0699da87b871db5ebcf7d91b3bb3e86b790fd981"
require linux-stable.inc
