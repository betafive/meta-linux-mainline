# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "2"
LINUX_VPATCH = "12"
LINUX_SHA256_TARBALL = "74862fa8ab40edae85bb3385c0b71fe103288bce518526d63197800b3cbdecb1"
LINUX_SHA256_PATCH = "acf7860badb149a0450e617465abf0dd20d11af517f1b4b473c3154a92029186"
require linux-stable.inc
