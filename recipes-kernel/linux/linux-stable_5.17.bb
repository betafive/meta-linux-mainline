# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "5"
LINUX_VMINOR = "17"
LINUX_VPATCH = "12"
LINUX_SHA256_TARBALL = "555fef61dddb591a83d62dd04e252792f9af4ba9ef14683f64840e46fa20b1b1"
LINUX_SHA256_PATCH = "6592348509bc9bbfdccdcbe94058411c03b5bd2fd573830c95be6b1fdb83630a"
require linux-stable.inc
