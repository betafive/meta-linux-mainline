# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "7"
LINUX_VMINOR = "3"
LINUX_VPATCH = "6"
SRCREV = "1a0388846138eda9f6eb4258ff227a223afc2f52"
require linux-stable.inc
