LINUX_VMAJOR = "5"
LINUX_VMINOR = "6"
LINUX_VPATCH = "17"
LINUX_SRCREV = "5117c0a56aeeb3ab18fb91bd611e739fec3df9c0"
LINUX_SHA256 = "c33a245401db38de760a7229cf3917eb6e6f8fabab0dc5add95b9b8f3e557f9e"

require linux-stable.inc
