LINUX_VMAJOR = "5"
LINUX_VMINOR = "3"
LINUX_VPATCH = "18"
LINUX_SRCREV = "d4f3318ed8fab6316cb7a269b8f42306632a3876"
LINUX_SHA256 = "20f14917c4f33122cfa12963a7d3180fe6f4685cacfe984553b2b5b4ad20638c"

require linux-stable.inc
