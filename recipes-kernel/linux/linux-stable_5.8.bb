LINUX_VMAJOR = "5"
LINUX_VMINOR = "8"
LINUX_VPATCH = "9"
LINUX_SRCREV = "f82f36b2fb1ddb42102bba34336d8038a946dd54"
LINUX_SHA256 = "99d8bc1b82f17d7d79f9af4a94af4c0e3772159e9e6e278761bde8569f93e15f"

require linux-stable.inc
