# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "12"
LINUX_VPATCH = "119"
SRCREV = "e2e4b92c2b2a3ae78423cb343951cb5d2241b405"
require linux-stable.inc
