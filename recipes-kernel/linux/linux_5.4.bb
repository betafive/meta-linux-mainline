LINUX_VMAJOR = "5"
LINUX_VMINOR = "4"
LINUX_VPATCH = "38"
LINUX_SRCREV = "9895e0ac338a8060e6947f897397c21c4d78d80d"
LINUX_SHA256 = "e72b9fa4e3a222d42d64dce9915e5b18f1b75ae722d529a1e560ced2e5d0f30e"

require kernel-dot-org.inc
