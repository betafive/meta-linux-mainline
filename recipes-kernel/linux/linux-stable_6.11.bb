# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "11"
LINUX_VPATCH = "1"
LINUX_SHA256_TARBALL = "55d2c6c025ebc27810c748d66325dd5bc601e8d32f8581d9e77673529bdacb2e"
LINUX_SHA256_PATCH = "e209cd7f59dd57a6c5c3c6ce5bc7c494401a695e323e635e2a62c708c07095c0"
require linux-stable.inc
