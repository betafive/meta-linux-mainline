LINUX_VMAJOR = "5"
LINUX_VMINOR = "9"
LINUX_VPATCH = "12"
LINUX_SRCREV = "89bb11da843beec4a6004ef7ecfa44b83a68b56c"
LINUX_SHA256 = "d97f56192e3474c9c8a44ca39957d51800a26497c9a13c9c5e8cc0f1f5b0d9bd"

require linux-stable.inc
