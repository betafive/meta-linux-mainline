# Copyright meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "7"
LINUX_VMINOR = "2"
LINUX_VPATCH = "15"
SRCREV = "497791a0a96b866d90add64041c47acdff49cae6"
require linux-stable.inc
